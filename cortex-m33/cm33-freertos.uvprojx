# Keil uVision project cm33-freertos.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: cm33-freertos +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: MSC_CLOCK,__DBG_ITM
  c include: .\Drivers\include\leo;.\RTE\Include;.\Drivers\include;.\Drivers\include\leo;.\Drivers\include\CMSIS;.\Drivers\src\FWCAN010
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x10000 size 0x10000
  memory RVCT10: RAM 0x20200000 size 0x20000
  group Source Group 1
    ./src/: main.c yaoxin.c PWMTMR010_main.c I2C_main.c SEMAPHORE_main.c IP_test_main.c GPIO010_main.c memtest.c DMAC020_main.c fpu_itm.c SSP_SPI_main.c I2S_main.c KBC_main.c UART_DMA_main.c PWMTMR_DMA_main.c SPI2AHB_main.c WDT011_main.c eFuse_main.c
  group Drivers
    ./Drivers/src/: DrvPWMTMR010.c DrvUART010.c DrvGPIO010.c DrvSemaphore.c DrvI2C_ftiic020.c utility.c DrvDMAC020.c DrvKBC010.c DrvSSP010.c ftssp010.c Driver_SAI.c wm8731.c DrvWDT011.c
software components: RTOS:Config 10.2.0, RTOS:Core 10.2.0, RTOS:Coroutines 10.2.0, RTOS:Event Groups 10.2.0, RTOS:Heap 10.2.0, RTOS:Timers 10.2.0, CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0, CMSIS:RTOS2:FreeRTOS 10.2.0, Device:Startup 1.2.0, Compiler:I/O:STDIN 1.4.0, Compiler:I/O:STDOUT 1.4.0, CMSIS Driver:I2C:Multi-Slave 1.0.1
